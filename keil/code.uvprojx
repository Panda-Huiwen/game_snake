# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: code
  AfterMake: fromelf -cvf .\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\code.axf -o code.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group include
    ../keil_src/: code_def.h delay.h font.h hongwai.h keyboard.h seg.h snake.h systick.h vga.h timer.h lcd.h music.h
  group source
    ../keil_src/: code_def.c delay.c hongwai.c keyboard.c main.c seg.c snake.c systick.c vga.c timer.c lcd.c music.c
  group startup
    ./: startup_CMSDK_CM0.s
